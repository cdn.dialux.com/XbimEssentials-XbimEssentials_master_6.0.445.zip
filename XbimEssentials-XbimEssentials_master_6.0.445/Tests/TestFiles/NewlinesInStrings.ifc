Properties of the parts of a building model (IFC2X3)

# File
Description: (('ViewDefinition [CoordinationView_V2.0]'),'2;1 ')
File name: 12_16
Time: 2012-05-31T11:18:08-04:00
Author: CB
Organization: Xbim Testing Inc.
Written by: ST-DEVELOPER v10-HandWritten
Made in: StruCad v16.4+CB
Comment: Edited by hand after being * Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: description
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcProject, 12_16
Description: undefined

# IfcMember: Cleat, L4x4x3/8
Description: L4x4x3/8
